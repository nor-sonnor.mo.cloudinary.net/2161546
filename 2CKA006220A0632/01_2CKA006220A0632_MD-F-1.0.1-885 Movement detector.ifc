Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2024-10-14T17:32:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Oct 14 17:32:33 2024 * Host: DESKTOP-QJ1AI03 * Database: C:\Users\ROBERT~1\AppData\Local\Temp\{3484CE40-5E50-467D-9518-EBCDAF5C5E91}\ifc * Database version: 5507 * Database creation date: Mon Oct 14 17:32:32 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Oct 14 17:32:32 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Oct 14 17:32:32 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto

# IfcBuildingStorey, Livello 1
LongName: Livello 1; Elevation: 0 mm
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Solido; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello 1; Famiglia e tipo: Livello: Livello 1; ID tipo: Livello: Livello 1; Tipo: Livello: Livello 1
Dati identità - Nome: Livello 1; Piano edificio: no; Strutturale: no
Dimensioni - Altezza di calcolo: 0 mm
Vincoli - Quota altimetrica: 0 mm
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello 1

# IfcBuildingElementProxy: 2CKA001754A4532_Cover Frame 1gang black matt, Future linear, 1-gang frame:2CKA001754A4532_Cover Frame 1gang black matt:5190
In: Livello 1
Type - Classification: 2CKA001754A4532 (Uniformat); Material: ABB_Black
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Future linear, 1-gang frame
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: Cover Frame 1gang black matt - future linear; ABB_EANCODE: 4011395175972; ABB_ETIM 7 Logical Attributes: With hinged lid, Label space/information surface, Suitable for floor box, Transparent, Suitable for built-in installation, With mounting grid, Halogen free, Suitable for wall duct, Suitable for flush-mounted installation; ABB_PRODUCT_ID: 2CKA001754A4532; ABB_Product Main Type: future® linear Cover frame; Codice assieme: 2CKA001754A4532; Descrizione: With small corner radii for trunking systems.; Modello: Future linear; Nome del tipo: 2CKA001754A4532_Cover Frame 1gang black matt; Produttore: ABB; URL: https://new.abb.com/low-voltage/products/building-automation/product-range/abb-i-bus-knx/products/visualisation-display-and-signalling/abb-smarttouch-10
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_Black
Type - Vincoli - Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA001754A4532_Cover Frame 1gang black matt
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: no; Famiglia: Future linear, 1-gang frame: 2CKA001754A4532_Cover Frame 1gang black matt; Famiglia e tipo: Future linear, 1-gang frame: 2CKA001754A4532_Cover Frame 1gang black matt; ID tipo: Future linear, 1-gang frame: 2CKA001754A4532_Cover Frame 1gang black matt; Tipo: Future linear, 1-gang frame: 2CKA001754A4532_Cover Frame 1gang black matt
Dati identità - Contrassegno: 2
Dimensioni - Area: 0.00837356 m2; Volume: 0.0000747975 m3
Elettrico - Carichi - Fattore di richiesta totale: 1; Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Nessuno; Sposta con l'oggetto più vicino: no

# IfcBuildingElementProxy: 2CKA006220A0632_MD-F-1.0.1-885 Movement detector, Movement detector, Future linear:2CKA006220A0632_MD-F-1.0.1-885 Movement detector:5189
In: Livello 1
Type - Classification: 2CKA006220A0632 (Uniformat); Material: ABB_Black, ABB_Glass, ABB_White, ABB_Gray, ABB_Logo Material
Type - Altro - Categoria: Attrezzatura elettrica; Nome famiglia: Movement detector, Future linear
Type - Dati - ABB_Auxiliary Voltage AC/DC: -; ABB_Degree of Protection: IP20
Type - Dati identità - ABB_Catalog Description: MD-F-1.0.1-885 Movement detector; ABB_EANCODE: 4011395204658; ABB_ETIM 7 Logical Attributes: Radio frequent bidirectional, Staircase monitoring, Bus connection included, Animal zone, Response value luminosity adjustable; ABB_PRODUCT_ID: 2CKA006220A0632; ABB_Product Main Type: Movement detector; Codice assieme: 2CKA006220A0632; Descrizione: With select lens for detection with animal access. For automatic switching of ABB-free@home® actuators dependent on movement and brightness. Switch-off delay of the actuator can be programmed via the web interface of the System Access Point. The bus can be connected via enclosed terminal block.; Modello: Movement detector, Future linear; Nome del tipo: 2CKA006220A0632_MD-F-1.0.1-885 Movement detector; Produttore: ABB; URL: https://new.abb.com/products/2CKA006220A0632/md-f-1-0-1-885
Type - Materiali e finiture - ABB_Logo Material: ABB_Logo Material; ABB_Material: ABB_Black
Type - Vincoli - Frame: Future linear, 1-gang frame: 2CKA001754A4532_Cover Frame 1gang black matt; Prospetto di default: 1219.2 mm
Pset_BuildingElementProxyCommon - Reference: 2CKA006220A0632_MD-F-1.0.1-885 Movement detector
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Altro - ABB_Logo Visibility: yes; Famiglia: Movement detector, Future linear: 2CKA006220A0632_MD-F-1.0.1-885 Movement detector; Famiglia e tipo: Movement detector, Future linear: 2CKA006220A0632_MD-F-1.0.1-885 Movement detector; ID tipo: Movement detector, Future linear: 2CKA006220A0632_MD-F-1.0.1-885 Movement detector; Tipo: Movement detector, Future linear: 2CKA006220A0632_MD-F-1.0.1-885 Movement detector
Dati identità - Contrassegno: 1
Dimensioni - Area: 0.0113335 m2; Volume: 0.000194308 m3
Elettrico - Carichi - Fase A carico apparente: 0 W; Fase B carico apparente: 0 W; Fase C carico apparente: 0 W; Fattore di richiesta totale: 1; Richiesta totale stimata: 0 W; Totale collegato: 0 W
Elettrico - Circuiti - Dati elettrici: 0 V/1-0 VA
Fasi - Fase di creazione: Nuova costruzione
Vincoli - Host: Nessuno; Prospetto: 0 mm
